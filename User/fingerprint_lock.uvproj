# Keil uVision project fingerprint_lock.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: fingerprint_lock
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\FWlib\inc;..\Public;..\FWlib\src;..\CMSIS\CM3\CoreSupport;..\FWlib\src;..\HardWare\key;..\HardWare\motor;..\HardWare\lis3dh;..\HardWare\spi;..\FWlib\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartCode
    ./: STM32F10x.s
  group User
    ./: main.c
  group HardWare
    ../HardWare/key/: key.c
    ../HardWare/motor/: motor.c
    ../HardWare/lis3dh/: lis3dh_driver.c
    ../HardWare/spi/: spi.c
  group Public
    ../Public/: system.c SysTick.c
    ../FWlib/src/: misc.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
